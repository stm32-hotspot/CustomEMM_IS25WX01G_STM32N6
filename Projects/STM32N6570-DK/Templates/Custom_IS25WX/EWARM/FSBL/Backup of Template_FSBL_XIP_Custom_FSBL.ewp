# IAR project Backup of Template_FSBL_XIP_Custom_FSBL.ewp, settings and files
configuration Template_FSBL_XIP_Custom_FSBL (ARM, debug)
  General.OGChipSelectEditMenu: STM32N657X0 ST STM32N657X0
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 63
  General.FPU2: 7
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32N657xx; NO_OTP_FUSE; DEBUG_TRACE
  ICCARM.CCIncludePath2: ../../FSBL/Inc; ../../../../../../Middlewares/ST/STM32_ExtMem_Manager; ../../../../../../Middlewares/ST/STM32_ExtMem_Manager/custom; ../../../../../../Drivers/STM32N6xx_HAL_Driver/Inc; ../../../../../../Drivers/CMSIS/Device/ST/STM32N6xx/Include; ../../../../../../Drivers/STM32N6xx_HAL_Driver/Inc/Legacy; ../../../../../../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Template_FSBL_XIP_Custom_FSBL.bin
  ILINK.IlinkOutputFile: Template_FSBL_XIP_Custom_FSBL.out
  ILINK.IlinkIcfFile: stm32n657xx_axisram2_fsbl.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../: startup_stm32n657xx_fsbl.s
  group Application/User/FSBL
    ../../FSBL/Src/: extmem_manager.c main.c stm32n6xx_hal_msp.c stm32n6xx_it.c
  group Doc
    ../../: README.md
  group Drivers/CMSIS
    ../../FSBL/Src/: system_stm32n6xx_fsbl.c
  group Drivers/STM32N6xx_HAL_Driver
    ../../../../../../Drivers/STM32N6xx_HAL_Driver/Src/: stm32n6xx_hal.c stm32n6xx_hal_bsec.c stm32n6xx_hal_cortex.c stm32n6xx_hal_dma.c stm32n6xx_hal_dma_ex.c stm32n6xx_hal_exti.c stm32n6xx_hal_gpio.c stm32n6xx_hal_pwr.c stm32n6xx_hal_pwr_ex.c stm32n6xx_hal_rcc.c stm32n6xx_hal_rcc_ex.c stm32n6xx_hal_uart.c stm32n6xx_hal_uart_ex.c stm32n6xx_hal_xspi.c
  group Middlewares/STM32_ExtMem_Manager
    ../../../../../../Middlewares/ST/STM32_ExtMem_Manager/: stm32_extmem.c
  group Middlewares/STM32_ExtMem_Manager/boot
    ../../../../../../Middlewares/ST/STM32_ExtMem_Manager/boot/: stm32_boot_xip.c
  group Middlewares/STM32_ExtMem_Manager/custom
    ../../../../../../Middlewares/ST/STM32_ExtMem_Manager/custom/: stm32_custom_driver.c
